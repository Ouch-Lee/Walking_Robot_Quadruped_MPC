Commit message: 综合jyt添加到代码和之前未更新到代码
1. 修改body质量为9.5？
2. 添加代码使得对每条腿力矩控制赋予不同的增益 k 和 b

File: mini_cheetah2.urdf (robot description, URDF)
Before this commit: robot mini_cheetah, 17 links, 16 joints
Links:
- link body: mass 3.3 -> 9.5
